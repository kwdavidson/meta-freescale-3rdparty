SRCBRANCH_sx8m = "cgtimx8mm__imx_4.14.98_2.0.0_ga"
IMX_MKIMAGE_SRC_sx8m = "git://git@git.congatec.com/arm-nxp/imx8-family/misc/mkimage-imx8-family.git;protocol=https"
SRCREV_sx8m = "31873a3517fe34feb11c90ae7746684d347f8dbc"
